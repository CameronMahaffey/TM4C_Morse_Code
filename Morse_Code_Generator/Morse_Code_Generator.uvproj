# Keil uVision project Morse_Code_Generator.uvproj, settings and files
target Morse Code Generator (ARM-ADS)
  device: TM4C1230C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LCD_Example
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Src
    ./: startup_TM4C123.s delay.c LCD.c PLL.c UART.c Morse_Code_Main.c DAC.c Morse.c PortF_LED_SW.c
